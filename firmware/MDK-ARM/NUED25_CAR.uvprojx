# Keil uVision project NUED25_CAR.uvprojx, settings and files
target NUED25_CAR (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUED25_CAR +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c misc: -Wno-invalid-source-encoding -Wno-pointer-sign
  c include: ..\;..\drivers\lcd;..\drivers\motor;..\drivers\line_sensor;..\drivers\key;..\drivers\imu;..\control;..\platform
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  group Source
    ../: NUED25_CAR.c ti_msp_dl_config.h ti_msp_dl_config.c NUED25_CAR.syscfg main.h
    ./: startup_mspm0g350x_uvision.s
  group LCD
    ../drivers/lcd/: lcd_init.c lcd.c
  group Platform
    ../platform/: clock.c
  group LineSensor
    ../drivers/line_sensor/: line_sensor.c
  group Motor
    ../drivers/motor/: motor.c
  group Key
    ../drivers/key/: key.c
  group IMU
    ../drivers/imu/: bsp_imu.c imu_ahrs_core.c inv_imu_driver.c inv_imu_transport.c
  group Control
    ../control/: pid.c
